# Keil uVision project AP.uvprojx, settings and files
target HT32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HT32F0006_64LQFP Holtek
  pack: Holtek.HT32_DFP.1.0.16
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x1FE00) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: AP +hex
  AfterMake: fromelf --bin -o "#L.bin" "#L"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HT32_DRIVER, USE_HT32F0006_DVB, USE_HT32F0006, USE_MEM_HT32F0006, HSE_VALUE=8000000,_48M
  c include: ..\;..\..\library\CMSIS\Include;..\..\library\Device\Holtek\HT32F5xxxx\Include;..\..\library\HT32F5xxxx_Driver\inc;..\..\library\HT32F5xxxx_Driver\src;..\..\library\HT32_USBD_Library\inc;..\..\utilities;..\AP\MIDI;..\AP\IAP;..\AP\Software;..\AP\System;..\AP\VCP;..\AP\BLE;..\AP\Interface;..\AP\Audio;..\AP\
  asm define: USE_HT32_CHIP=10
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1fe00
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\linker.lin
  link misc: --entry Reset_Handler
  group IAP
    ../AP/IAP/: buffer.c crc16.c iap_handler.c
  group User
    ../AP/: ht32f5xxxx_01_it.c main.c
    ../../library/HT32_USBD_Library/src/: ht32_usbd_core.c
    ../AP/Software/: URBus.c sys_timer.c Power.c
  group MIDI
    ../AP/MIDI/: key_func.c QSPI_flash.c QSPI_MIDICTRL.c timer.c tone_offset_sys.c User_Midi_Subr.c user_table.c tone_table.c audio_index.c amidi_200407_audio2.lib
  group Interface
    ../AP/Interface/: ADC.c GPIO.c i2c.c
  group BLE
    ../AP/BLE/: bc76xx.c bleprocess.c bleuser.c bleApp.c
  group MPU6050
    ../AP/Software/: MPU6050.c
  group Config
    ./: ht32_op.s HT32F5xxxx_01_DebugSupport.ini
    ../AP/System/: ht32f5xxxx_conf.h
  group CMSIS
    ../../library/Device/Holtek/HT32F5xxxx/Source/: system_ht32f0006.c
  group MDK-ARM
    ./: startup_ht32f5xxxx_01.s
  group Retarget
    ../AP/VCP/: ht32_retarget.c ht32_serial.c
  group Utilities
    ../../utilities/: ht32_board.c
    ../../utilities/common/: i2c_eeprom.c spi_flash.c
  group Library
    ../../library/HT32F5xxxx_Driver/src/: ht32_cm0plus_misc.c ht32f5xxxx_adc.c ht32f5xxxx_bftm.c ht32f5xxxx_ckcu.c ht32f5xxxx_crc.c ht32f5xxxx_dac_dual16.c ht32f5xxxx_div.c ht32f5xxxx_exti.c ht32f5xxxx_flash.c ht32f5xxxx_gpio.c ht32f5xxxx_i2c.c ht32f5xxxx_i2s.c ht32f5xxxx_mctm.c ht32f5xxxx_pdma.c ht32f5xxxx_pwrcu.c ht32f5xxxx_rstcu.c ht32f5xxxx_rtc.c ht32f5xxxx_spi.c ht32f5xxxx_tm.c ht32f5xxxx_usart.c ht32f5xxxx_usbd.c ht32f5xxxx_wdt.c ht32f5xxxx_midi.c
